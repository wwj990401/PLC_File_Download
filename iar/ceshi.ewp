# IAR project ceshi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F765NI ST STM32F765NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F765xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\app; ..\cmsis; ..\drivers\inc; ..\ucos\CONFIG; ..\ucos\CORE; ..\ucos\PORT; ..\hardware\led; ..\system\sys; ..\hardware\sdram; ..\malloc; ..\system\delay; ..\system\usart; ..\usmart; ..\hardware\lan8720; ..\hardware\pcf8574; ..\hardware\iic; ..\lwip\lwip-1.4.1\src\include; ..\lwip\lwip-1.4.1\src\include\ipv4; ..\lwip\lwip-1.4.1\src\include\netif; ..\lwip; ..\lwip\arch; ..\lwip\lwip_app\lwip_comm; ..\hardware\timer; ..\hardware\mpu; ..\hardware\stm32flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Download.hex
  ILINK.IlinkOutputFile: ceshi.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f765xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group app
    ../app/: main.c main.h stm32f765xx.h stm32f7xx.h stm32f7xx_hal_conf.h stm32f7xx_it.c system_stm32f7xx.c
  group cmsis
    ../cmsis/: cmsis_armcc.h cmsis_compiler.h cmsis_iccarm.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h mpu_armv7.h
  group drivers
    ../drivers/src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_fmc.c
  group hardware
    ../hardware/lan8720/: lan8720.c
    ../hardware/led/: led.c
    ../hardware/mpu/: mpu.c
    ../hardware/sdram/: sdram.c
    ../hardware/stm32flash/: stmflash.c
  group iar
    ./: startup_stm32f765xx.s
  group lwip/lwip-api
    ../lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/lwip-app
    ../lwip/lwip_app/lwip_comm/: lwip_comm.c lwip_tcp_server_socket.c
  group lwip/lwip-arch
    ../lwip/arch/: sys_arch.c
  group lwip/lwip-core
    ../lwip/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/lwip-netif
    ../lwip/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group malloc
    ../malloc/: malloc.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group ucos/config
    ../ucos/CONFIG/: includes.h os_cfg.h
  group ucos/core
    ../ucos/CORE/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group ucos/port
    ../ucos/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group usmart
    ../usmart/: usmart.c usmart_config.c usmart_str.c
